VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO HBT_BOTIN_bottom
  CLASS COVER ;
  ORIGIN 0 0 ;
  FOREIGN HBT_BOTIN_bottom 0 0 ;
  SIZE 0.1 BY 0.1 ;
  SYMMETRY X Y ;
END HBT_BOTIN_bottom
MACRO HBT_TOPIN_bottom
  CLASS COVER ;
  ORIGIN 0 0 ;
  FOREIGN HBT_TOPIN_bottom 0 0 ;
  SIZE 0.1 BY 0.1 ;
  SYMMETRY X Y ;
END HBT_TOPIN_bottom
MACRO HBT_BOTIN_top
  CLASS COVER ;
  ORIGIN 0 0 ;
  FOREIGN HBT_BOTIN_top 0 0 ;
  SIZE 0.1 BY 0.1 ;
  SYMMETRY X Y ;
END HBT_BOTIN_top
MACRO HBT_TOPIN_top
  CLASS COVER ;
  ORIGIN 0 0 ;
  FOREIGN HBT_TOPIN_top 0 0 ;
  SIZE 0.1 BY 0.1 ;
  SYMMETRY X Y ;
END HBT_TOPIN_top
END LIBRARY
